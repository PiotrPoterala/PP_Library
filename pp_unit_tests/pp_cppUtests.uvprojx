# Keil uVision project pp_cppUtests.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pp_cppUtests
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: STM32F429xx
  c include: ..\PP_String_Library;..\..\PP_library;..\..\cppUtest\include;..\PP_Parameters_Library;..\PP_StepperMotor_Library;..\PP_Point;..\PP_IOdevice_library;..\PP_File_Library;..\..\PP_library_C\PP_Math;..\PP_Interpret_Gcode_Library;..\PP_TextStream_Library;..\PP_Math;..\PP_List_Library
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group PP_Parameters_Library
    ../: stm32xx.h
    ../PP_Parameters_Library/: pp_paramlist.cpp pp_param.cpp
    ../PP_Point/: pp_point.h
  group unit_test_lib
    ./: cpputest.lib
  group tests
    ./: AllTests.cpp pstring_test.cpp pdir_test.cpp pfile_test.cpp pfileInfo_test.cpp pp_motorslist_test.cpp pp_math_ext_test.cpp pp_point_test.cpp pp_edf_resolver_strategy_test.cpp pp_select_list_test.cpp pp_paramlist_test.cpp pp_gcode_resolver_strategy_test.cpp pp_drive_algorithms_test.cpp
  group PP_File_Library
    ../PP_File_Library/: pp_dir.cpp pp_file.cpp pp_file_info.cpp
  group PP _String_Library
    ../PP_String_Library/: pstring.cpp
  group PP_IOdevice_library
    ../PP_IOdevice_library/: pp_iodevice.h
  group mocks
    ../PP_File_Library/: pp_file_info_mock.h pp_dir_mock.h pp_file_mock.cpp pp_file_string_mock.cpp
  group PP_Motor_library
    ../PP_StepperMotor_Library/: pp_motorslist.cpp pp_stepper_motor_2clock_driver.cpp pp_drive_algorithms.cpp pp_fast_drive_algorithms.cpp pp_path_drive_algorithms.cpp pp_control_coordinate_decorator.cpp
  group Math
    ../../PP_library_C/PP_Math/: pp_math.c
    ../PP_Math/: pp_math_ext.cpp pp_arc_ext.cpp
  group PP_Interpret_Gcode_Library
    ../PP_Interpret_Gcode_Library/: pp_prog_gcode_resolver_strategy.cpp pp_program_resolver_strategy.h pp_prog_wedm_gcode_resolver_strategy.cpp pp_prog_edf_resolver_strategy.cpp
  group PP_TextStream_Librarry
    ../PP_TextStream_Library/: pp_text_stream.cpp
  group PP_List_Library
    ../PP_List_Library/: pp_select_list.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.2
